options:
  parameters:
    generate_options: no_gui
    id: range_doppler_gr_cedr
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: vec_len
  id: variable
  parameters:
    value: '128'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: matched_filter.bin
    repeat: 'True'
    type: complex
    vlen: vec_len
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: rx_pulses.bin
    repeat: 'True'
    type: complex
    vlen: vec_len
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
    vlen: vec_len
  states: {}
- name: cedr_fft_0
  id: cedr_fft
  parameters:
    direction: 'False'
    vlen: vec_len
  states: {}
- name: cedr_fft_0_0
  id: cedr_fft
  parameters:
    direction: 'False'
    vlen: vec_len
  states: {}
- name: cedr_fft_0_0_0
  id: cedr_fft
  parameters:
    direction: 'True'
    vlen: vec_len
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:50002
    timeout: '100'
    type: complex
    vlen: vec_len
  states: {}

connections:
- [blocks_file_source_0, '0', cedr_fft_0, '0']
- [blocks_file_source_0_0, '0', cedr_fft_0_0, '0']
- [blocks_multiply_xx_0, '0', cedr_fft_0_0_0, '0']
- [cedr_fft_0, '0', blocks_multiply_xx_0, '0']
- [cedr_fft_0_0, '0', blocks_multiply_xx_0, '1']
- [cedr_fft_0_0_0, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0-rc1
