options:
  parameters:
    generate_options: no_gui
    id: gr_py_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
